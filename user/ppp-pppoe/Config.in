## user/ppp-pppoe/Config.in
```kconfig
#####################
config OPENSOURCE_PPPD
	bool 'PPP Daemom'
	default y
	depends OPENSOURCE
  	help 
      	PPP Daemom
```
